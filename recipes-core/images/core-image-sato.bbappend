IMAGE_INSTALL += "rtsp-client.1.0 vsomeip"
